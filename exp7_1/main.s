; INCLUDE VICVPB.S
IO0PIN EQU 0xE0028000 
IO0SET EQU 0xE0028004 
IO0DIR EQU 0xE0028008 
IO0CLR EQU 0xE002800C 
IO1PIN EQU 0xE0028010 
IO1SET EQU 0xE0028014 
IO1DIR EQU 0xE0028018 
IO1CLR EQU 0xE002801C


	AREA CHANG, CODE, READONLY
	EXPORT __main

__main
	ENTRY
		; Configure P0.7 as output
		LDR r1, =IO0DIR
		LDR r0, =0XFF0000     ; Bit 7 set for P0.7
		STR r0, [r1]

		; Load IOCLR and IOSET addresses
		LDR r2, =IO0CLR
		LDR r3, =IO0SET

BACK
		STR r0, [r2]            ; Clear P0.7 (LOW)
		BL DELAY
		STR r0, [r3]            ; Set P0.7 (HIGH)
		BL DELAY
		B BACK

DELAY
		LDR r5, =0x2FFF
WAIT
		SUBS r5, r5, #1
		BNE WAIT
		BX LR
		END