IO0DIR EQU  0xE0028008
IO0SET EQU  0xE0028004
IO0CLR EQU  0xE002800C

	AREA CHANG,CODE,READONLY
	EXPORT __main
__main
	ENTRY
		LDR r1,=IO0DIR
		LDR r0,=0xF0FF0000
		STR r0,[r1]
		LDR r2,=IO0SET
		LDR r3,=IO0CLR
S	    STR R0,[R3]
		LDR R1,=0X803F0000
		STR R1,[R2]
		BL DELAY
		STR R0,[R3]
	    LDR R1,=0X40060000
		STR R1,[R2]
		BL DELAY
		STR R0,[R3]
		LDR R1,=0X205B0000
		STR R1,[R2]
		BL DELAY
		STR R0,[R3]
		LDR R1,=0X104F0000
		STR R1,[R2]
		BL DELAY
		B S
DELAY   LDR R5,=0X2FF
delay   SUBS R5,R5,#1
		BNE delay
		BX LR
		END